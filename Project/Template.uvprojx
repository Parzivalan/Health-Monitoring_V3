# Keil uVision project Template.uvprojx, settings and files
target Target1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\HARDWARE\inc;..\User\SYSTEM\segger_rtt;..\User\NET\device;..\User\NET\MQTT;..\User\NET\onenet;..\User\SYSTEM\delay;..\User\SYSTEM\sys;..\User\SYSTEM\usart;..\User\HARDWARE\mpu6050\eMPL;..\User\HARDWARE\mpu6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: stm32f10x_it.c main.c
  group DOC
    ../Doc/: readme.txt
  group HARDWARE
    ../User/HARDWARE/src/: ads1115.c adc.c oled.c beep.c led.c timer.c algorithm.c max30102.c myiic.c
    ../User/HARDWARE/mpu6050/: mpu6050.c mpuiic.c
    ../User/HARDWARE/mpu6050/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
  group SYSTEM
    ../User/SYSTEM/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../User/SYSTEM/delay/: delay.c
    ../User/SYSTEM/sys/: sys.c
    ../User/SYSTEM/usart/: usart.c
  group NET
    ../User/NET/device/: esp8266.c
    ../User/NET/MQTT/: MqttKit.c
    ../User/NET/onenet/: onenet.c
